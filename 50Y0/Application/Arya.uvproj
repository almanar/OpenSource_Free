# Keil uVision project Arya.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Arya +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin --output Arya.bin Arya.axf
  c flags: Optim=1 wLevel=2
  asm define: REMAP RAM_MODE RAM_INTVEC SIZE_INT_INFO
  memory RVCT4: ROM 0x8000 size 0x80000
  memory RVCT9: RAM 0x40000040 size 0x8000
  group Source Group 1
    ./: LPC214x.h Startup.s types.h irq.c
  group Globals
    ./: global.c
  group Timer
    ./: timer.c
  group Spi
    ./: spi.c
  group Uart
    ./: uart.c
  group DataFlash
    ./: dataflash.c
  group Lcd
    ./: lcd.c
  group Keypad
    ./: keypad.c
  group ExtInt
    ./: extint.c
  group WDT
    ./: wdt.c
  group CardReader
    ./: cardreader.c
  group MiscFunctions
    ./: MiscFunctions.c
  group Application
    ./: app.c
  group Meter
    ./: Meter.c
